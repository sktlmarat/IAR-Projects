<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LED Blink advanced.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\LED Blink using structs and CMSIS\Struct.ewp</path>
    </project>
    <batchBuild />
</workspace>
